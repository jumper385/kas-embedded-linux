# remove demo apps
PACKAGE_INSTALL:remove = "linux-examples-stm32mp1-userfs packagegroup-st-demo"
